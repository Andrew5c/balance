# Keil uVision project Electronic_balance.uvprojx, settings and files
target electronic_balance (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Electronic_balance
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\CMSIS\startup;.\FWlib\inc;.\USER;.\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c KEY.c balance.c CS1237.c filter.c beep.c HMI.c power.c LED.c ds1302.c OLED.c word.c battery.c ADC.c flash.c USART1.c USART2.c client.c usart2printf.c
  group SYSTEM
    ./SYSTEM/: delay.c least_square.c stm32f10x_it.c
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group FLIB
    ./FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_flash.c
